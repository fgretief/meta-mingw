EXTRA_OECONF_append = " --disable-plugins"